# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\SOFTWARE\APP;.\SOFTWARE\BSP;.\SOFTWARE\DRIVER;.\SOFTWARE\FWLib\INC;.\SOFTWARE\FWLib\M3;.\SOFTWARE\uCOS-III\uC-CPU;.\SOFTWARE\uCOS-III\uC-LIB;.\SOFTWARE\uCOS-III\uCOS-III;.\SOFTWARE\uCGUI\Config;.\SOFTWARE\uCGUI\GUIDemo;.\SOFTWARE\uCGUI\LCDDriver;.\SOFTWARE\uCGUI\GUI;.\SOFTWARE\user\INC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group BSP
    ./SOFTWARE/FWLib/Startup/: startup_stm32f10x_hd.s
    ./SOFTWARE/BSP/: bsp.c
  group FWLib
    ./SOFTWARE/FWLib/SRC/: stm32f10x_wwdg.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c stm32f10x_adc.c misc.c
    ./SOFTWARE/FWLib/M3/: stm32f10x_it.c core_cm3.c system_stm32f10x.c
  group USER
    ./SOFTWARE/user/MAIN/: main.c
    ./SOFTWARE/user/LOAD/: LOAD.c
    ./SOFTWARE/user/SYS_INIT/: SYS_INIT.c
    ./SOFTWARE/user/JIARE/: JIARE.c
    ./SOFTWARE/user/MODBUS/: MODBUS.c
    ./SOFTWARE/user/SENSOR/: SENSOR.c
    ./SOFTWARE/user/SHUCHU/: SHUCHU.c
    ./SOFTWARE/user/LCD/: LCD.c
    ./SOFTWARE/user/KEY/: KEY.c
    ./SOFTWARE/user/SHEZHI/: SHEZHI.c
